## boards/shields/custom_nice_view/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_SHIELD_BASE
    def_bool $(shields_list_contains,custom_nice_view)
```
